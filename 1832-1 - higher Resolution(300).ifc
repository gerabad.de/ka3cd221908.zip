Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_3/temp/tmp_32_43_rBpxc/format_2/1832-1 - higher Resolution(300).ifc
Time: 2023-04-26T08:54:27
Made in: PARTsolutions

# IfcProject, 1832-1 - higher Resolution(300)
Description: SUPERPLAN

# IfcDiscreteAccessory, 1832-1 - higher Resolution(300)
In: BUILDING
Description: 1832-1 - higher Resolution(300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 1832-1
ePset_PARTsolutions - NB: 1832-1 - higher Resolution(300); NN: 1832-1 higher resolution; NT: SUPERPLAN; NBSYN: $A. - higher Resolution($LODLEVEL.); LINA: 1832-1 - higher Resolution(300); CATALOG: Kaldewei; A: 1832-1; LODLEVEL: 300; B: freisteller_superplan_140x90_alpinweiss.png; C: SUPERPLAN; D: 16,4; E: KALDEWEI; F: Ablaufgarnitur KA90 Art.:687772560999; G: Web PDF; H: all countrys; I: 30; J: -; K: -; L: -; M: -; N: -; O: -; P: EC011443 (Showertray); EF002169: EV000179 (steel); EF000139: EV002029 (enamelled); EF000051: EV000220 (rectangular); EF000049: 800; EF004567: 750; EF000040: 25
